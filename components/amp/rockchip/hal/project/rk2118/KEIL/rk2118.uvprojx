# Keil uVision project rk2118.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: rk2118 +hex
  AfterMake: fromelf --bin --output Objects\rk2118.bin Objects\rk2118.axf
  AfterMake: fromelf -c  Objects\rk2118.axf -o Objects\rk2118.asm
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c misc: -Wno-comment -Wno-c99-extensions -Wno-long-long -Wno-pedantic -Wno-covered-switch-default -Wno-switch-enum -Wno-padded -Wno-covered-switch-default
  c include: ..\..\..\lib\CMSIS\Core\Include;..\..\..\lib\CMSIS\Device\RK2118\Include;..\..\..\lib\hal\inc;..\..\..\lib\bsp\RK2118;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x11060800 size 0x3f800
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x30204000 size 0x1b000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ..\..\..\lib\CMSIS\Device\RK2118\Source\Templates\ARM\rk2118_ac6.sct
  group Source Group 1
    ../src/: hal_conf.h main.c test_conf.h
    ../../../lib/CMSIS/Device/RK2118/Source/Templates/ARM/: startup_rk2118.S
    ../../../lib/CMSIS/Device/RK2118/Source/Templates/: system_rk2118.c
    ../../../lib/hal/src/: hal_acdcdig.c hal_acdcdig_dsm.c hal_acdcdigv2.c hal_asrc.c hal_audiopwm.c hal_base.c hal_base_ex.c hal_bufmgr.c hal_cache.c hal_cache_ecc.c hal_canfd.c hal_ckcal.c hal_cpu_topology.c hal_ddr_ecc.c hal_debug.c hal_demo.c hal_dsmc_host.c hal_dsmc_slave.c hal_dwdma.c hal_efuse.c hal_ehci.c hal_ehci_iso.c hal_facc.c hal_fspi.c hal_gic.c hal_gpio.c hal_gpio_irq_group.c hal_hcd.c hal_hwspinlock.c hal_hyperpsram.c hal_i2c.c hal_i2s.c hal_i2stdm.c hal_intmux.c hal_irq_handler.c hal_keyctrl.c hal_mbox.c hal_nvic.c hal_ohci.c hal_otp.c hal_pcd.c hal_pcd_ex.c hal_pci_core.c hal_pcie.c hal_pd.c hal_pdm.c hal_pdm_v2.c hal_pl330.c hal_pvtm.c hal_pwm.c hal_pwr.c hal_qpipsram.c hal_riscvic.c hal_rknpu.c hal_sai.c hal_saradc.c hal_sdio.c hal_sfc.c hal_smccc.c hal_snor.c hal_spdifrx.c hal_spdiftx.c hal_spi.c hal_spi2ahb.c hal_spi2apb.c hal_spinand.c hal_spinlock.c hal_systick.c hal_timer.c hal_touchkey.c hal_trng.c hal_tsadc.c hal_uart.c hal_usb_core.c hal_usb_phy.c hal_usbh.c hal_vad.c hal_vdma.c hal_vicap.c hal_wdt.c
    ../../../lib/hal/src/cru/: hal_cru.c hal_cru_rk2118.c hal_cru_swallow.c
    ../../../lib/hal/src/pinctrl/: hal_pinctrl.c hal_pinctrl_iofunc.c hal_pinctrl_rk2118.c hal_pinctrl_v2.c
    ../../../lib/hal/src/pm/: hal_pm_cpu.c
    ../../../lib/bsp/RK2118/: hal_bsp.c hal_bsp.h hal_spinlock_id.h
    ../../../lib/hal/src/npor/: hal_npor_rk2118.c
